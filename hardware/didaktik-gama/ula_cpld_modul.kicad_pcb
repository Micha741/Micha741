# Repository Micha741/Micha741 (continued)

## KiCad design hardware/didaktik-gama/didaktik_gama.kicad_pcb

Schematic: didaktik_gama.kicad_sch, Didaktik Gama – schéma zapojení

Parts:
C1: 2u; CP_Radial_D5.0mm_P2.50mm
C2, C9, C10: 100p; C_Disc_D5.0mm_W2.5mm_P5.00mm
C3, C8: 47p; C_Disc_D5.0mm_W2.5mm_P5.00mm
C4: 10n; C_Disc_D5.0mm_W2.5mm_P5.00mm
C5, C6, C7, C12, C13, C20, C21, C22, C23, C24, C25, C26, C27, C28, C29, C30, C31, C32, C33, C34, C35, C36, C37, C38, C39, C40, C41, C42, C43, C44, C45, C46, C47, C48, C81, C82, C83, C84, C91, C93, C94, C95: 100n; C_Disc_D5.0mm_W2.5mm_P5.00mm
C11: 1000u/25V; CP_Radial_D10.0mm_P5.00mm
C14: 220u/10V; CP_Radial_D6.3mm_P2.50mm
C15: 10u/16V; CP_Radial_D5.0mm_P2.00mm
C60, C61: 47u/10V; CP_Radial_D5.0mm_P2.00mm
C85: 1u/16V; CP_Radial_D5.0mm_P2.00mm
C86, C87, C92: 10u/16V; CP_Radial_D6.3mm_P2.50mm
C88: 220u/16V; CP_Radial_D6.3mm_P2.50mm
C89: 47n; C_Disc_D5.0mm_W2.5mm_P5.00mm
C90: 100u/25V; CP_Radial_D6.3mm_P2.50mm
D1, D2, D3, D4, D5, D6, D7, D8, D9, D10, D11: KA136; D_DO-35_SOD27_P7.62mm_Horizontal
D12: 1N5822 (Schottky 3A); D_DO-201AD_P15.24mm_Horizontal
D13: LED zelená; LED_D5.0mm
F1: 1A T; Fuseholder_Cylinder-5x20mm_Stelvio-Kontek_PTF78_Horizontal_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
J1: Klávesnice; PinHeader_1x14_P2.54mm_Vertical
J2: MG; PinHeader_1x03_P2.54mm_Vertical
J4: Porty 8255; PinHeader_2x13_P2.54mm_Vertical
J5: Napájení 9–12V DC; BarrelJack_Horizontal
J7: VGA DE-15 (RGB 15 kHz); DSUB-15-HD_Female_Horizontal_P2.29x1.98mm_EdgePinOffset3.03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
J8: RGB + zvuk z modulu ULA; PinHeader_1x10_P2.54mm_Vertical
J9: Reproduktor 8 ohm; PinHeader_1x02_P2.54mm_Vertical
J10: Linkový výstup (jack 3,5 mm); Jack_3.5mm_CUI_SJ1-3523N_Horizontal
LS1: Reproduktor; PinHeader_1x02_P2.54mm_Vertical
R1, R2, R3, R10, R11, R12, R13, R14, R15, R84, R85, R86, R87, R88, R89, R90, R91, R92, R93, R94, R95, R96, R104: 10k; R_Axial_DIN0207_L6.3mm_D2.5mm_P10.16mm_Horizontal
R4: 220k; R_Axial_DIN0207_L6.3mm_D2.5mm_P10.16mm_Horizontal
R5, R6, R19, R20, R21, R22, R23, R24, R25, R26, R45: 470; R_Axial_DIN0207_L6.3mm_D2.5mm_P10.16mm_Horizontal
R7, R17, R98, R99, R100, R108: 1k; R_Axial_DIN0207_L6.3mm_D2.5mm_P10.16mm_Horizontal
R8: 180; R_Axial_DIN0207_L6.3mm_D2.5mm_P10.16mm_Horizontal
R9: 15; R_Axial_DIN0207_L6.3mm_D2.5mm_P10.16mm_Horizontal
R16, R76, R78, R80: 680; R_Axial_DIN0207_L6.3mm_D2.5mm_P10.16mm_Horizontal
R18: 330k; R_Axial_DIN0207_L6.3mm_D2.5mm_P10.16mm_Horizontal
R27, R28, R29, R30, R31, R32, R33: 330; R_Axial_DIN0207_L6.3mm_D2.5mm_P10.16mm_Horizontal
R34: 100; R_Axial_DIN0207_L6.3mm_D2.5mm_P10.16mm_Horizontal
R35, R36, R37, R38, R39, R40, R41, R42: 8k2; R_Axial_DIN0207_L6.3mm_D2.5mm_P10.16mm_Horizontal
R43, R44: 220; R_Axial_DIN0207_L6.3mm_D2.5mm_P10.16mm_Horizontal
R77, R79, R81: 1k5; R_Axial_DIN0207_L6.3mm_D2.5mm_P10.16mm_Horizontal
R82, R83: 75; R_Axial_DIN0207_L6.3mm_D2.5mm_P10.16mm_Horizontal
R97, R106: 2k2; R_Axial_DIN0207_L6.3mm_D2.5mm_P10.16mm_Horizontal
R101, R102, R103: 4k7; R_Axial_DIN0207_L6.3mm_D2.5mm_P10.16mm_Horizontal
R105: 100k; R_Axial_DIN0207_L6.3mm_D2.5mm_P10.16mm_Horizontal
R107: 10R; R_Axial_DIN0207_L6.3mm_D2.5mm_P10.16mm_Horizontal
R109: 47k; R_Axial_DIN0207_L6.3mm_D2.5mm_P10.16mm_Horizontal
RV1: 10k log (hlasitost); Potentiometer_Alps_RK09K_Single_Vertical
SW1: RESET; SW_PUSH_6mm
T1, T2: KSY72; TO-18-3
T3: KC507; TO-18-3
U1: UA880D (Z80); DIP-40_W15.24mm
U2: 27128 (16K EPROM); DIP-28_W15.24mm
U3: 8255 (MHB8255); DIP-40_W15.24mm
U4: ULA; DIP-40_W15.24mm
U5, U6, U7, U8: 74LS157; DIP-16_W7.62mm
U9, U10, U11, U12, U13, U14, U15, U16: 4164; DIP-16_W7.62mm
U17, U18, U19, U20, U21, U22, U23, U24: 2118; DIP-16_W7.62mm
U25, U26: 74LS04; DIP-14_W7.62mm
U27: 74LS00; DIP-14_W7.62mm
U28: 74LS10; DIP-14_W7.62mm
U29: 74LS32; DIP-14_W7.62mm
U32: R-78E5.0-1.0 (spínaný, náhrada 7805); Converter_DCDC_RECOM_R-78E-0.5_THT
U37: 74HCT244; DIP-20_W7.62mm
U38: 74HCT08; DIP-14_W7.62mm
U39: Raspberry Pi Pico (USB host); RaspberryPi_Pico_THT
U40: 74LVC245; SOIC-20W_7.5x12.8mm_P1.27mm
U41: 74LVC07; SOIC-14_3.9x8.7mm_P1.27mm
U42: YM2149F (nebo AY-3-8910); DIP-40_W15.24mm
U43: 74HCT11; DIP-14_W7.62mm
U44: 74HCT74; DIP-14_W7.62mm
U45: LM386N-1; DIP-8_W7.62mm
Y1: 14MHz; Crystal_HC49-4H_Vertical

Connections:
+3V3_KBD: C83.1, C84.1, R90.1, R91.1, R92.1, R93.1, R94.1, R95.1, U39.36 (3V3_OUT), U40.1 (DIR), U40.20 (VCC), U41.14 (VCC)
+5V: C13.1, C14.1, C15.1, C20.1, C21.1, C22.1, C23.1, C24.1, C25.1, C26.1, C27.1, C28.1, C29.1, C30.1, C31.1, C32.1, C33.1, C34.1, C35.1, C36.1, C37.1, C38.1, C39.1, C40.1, C41.1, C42.1, C43.1, C44.1, C45.1, C46.1, C47.1, C48.1, C60.1, C61.1, C81.1, C82.1, C93.1, C94.1, C95.1, D13.2, J4.25, J8.7, R1.1, R2.1, R3.1, R4.1, R8.1, R9.1, R10.1, R11.1, R12.1, R13.1, R14.1, R17.1, R35.1, R36.1, R37.1, R38.1, R39.1, R40.1, R41.1, R42.1, R88.1, R89.1, T1.3 (C), U1.11 (VCC), U2.1 (VPP), U2.27 (~PGM), U2.28 (VCC), U3.26 (VCC), U4.14 (VCC), U5.16 (VCC), U6.16 (VCC), U7.16 (VCC), U8.16 (VCC), U9.8 (VCC), U10.8 (VCC), U11.8 (VCC), U12.8 (VCC), U13.8 (VCC), U14.8 (VCC), U15.8 (VCC), U16.8 (VCC), U17.8 (VCC), U17.9 (VCC), U18.8 (VCC), U18.9 (VCC), U19.8 (VCC), U19.9 (VCC), U20.8 (VCC), U20.9 (VCC), U21.8 (VCC), U21.9 (VCC), U22.8 (VCC), U22.9 (VCC), U23.8 (VCC), U23.9 (VCC), U24.8 (VCC), U24.9 (VCC), U25.14 (VCC), U26.14 (VCC), U27.14 (VCC), U28.14 (VCC), U29.14 (VCC), U32.3 (OUT), U37.20 (VCC), U38.14 (VCC), U39.40 (VBUS), U42.25 (A8), U42.28 (BC2), U42.40 (VCC), U43.14 (VCC), U44.1 (~1CLR), U44.4 (~1PRE), U44.10 (~2PRE), U44.13 (~2CLR), U44.14 (VCC)
/BANKSEL: J1.14, U26.10
/BUSRQ: R3.2, U1.25 (~BUSRQ)
/CAS64: U9.15 (~CAS), U10.15 (~CAS), U11.15 (~CAS), U12.15 (~CAS), U13.15 (~CAS), U14.15 (~CAS), U15.15 (~CAS), U16.15 (~CAS), U29.6
/CS8255: U3.6 (~CS), U28.6
/INT: R6.1, U1.16 (~INT)
/INT_ULA: R6.2, U4.12 (~INT)
/IORQ: R5.1, U1.20 (~IORQ), U25.9
/IORQGE: R5.2, T1.1 (E), U4.33 (~IORQGE)
/M1: U1.27 (~M1), U28.5, U43.2 (1B)
/MREQ: C10.1, U1.19 (~MREQ), U4.38 (~MREQ), U29.1, U29.2, U29.13
/NMI: R1.2, U1.17 (~NMI)
/RAS64: R43.1, U9.4 (~RAS), U10.4 (~RAS), U11.4 (~RAS), U12.4 (~RAS), U13.4 (~RAS), U14.4 (~RAS), U15.4 (~RAS), U16.4 (~RAS), U29.3, U29.4
/RD: U1.21 (~RD), U2.22 (~OE), U3.5 (~RD), U4.3 (~RD), U27.4
/RESET: C1.1, R4.2, SW1.1, U1.26 (~RESET), U25.13, U41.12 (6Y), U42.23 (~RESET)
/RGB_CSYNC: J8.5, R88.2, U37.8 (1A3)
/RGB_VSYNC: J8.6, R89.2, U37.11 (2A3)
/ROMCS: C2.1, U2.20 (~CE), U4.34 (~ROMCS)
/SEL64: U27.8, U29.10
/VCAS: U4.1 (~CAS), U17.15 (~CAS), U18.15 (~CAS), U19.15 (~CAS), U20.15 (~CAS), U21.15 (~CAS), U22.15 (~CAS), U23.15 (~CAS), U24.15 (~CAS)
/VRAS: R34.1, U4.35 (~RAS), U17.4 (~RAS), U18.4 (~RAS), U19.4 (~RAS), U20.4 (~RAS), U21.4 (~RAS), U22.4 (~RAS), U23.4 (~RAS), U24.4 (~RAS)
/VWE: U4.4 (~WE), U17.3 (~WE), U18.3 (~WE), U19.3 (~WE), U20.3 (~WE), U21.3 (~WE), U22.3 (~WE), U23.3 (~WE), U24.3 (~WE)
/WAIT: R2.2, U1.24 (~WAIT)
/WE64: U9.3 (~WE), U10.3 (~WE), U11.3 (~WE), U12.3 (~WE), U13.3 (~WE), U14.3 (~WE), U15.3 (~WE), U16.3 (~WE), U29.11
/WR: U1.22 (~WR), U3.36 (~WR), U4.2 (~WR), U25.1, U29.12
A0: T1.2 (B), U1.30 (A0), U2.10 (A0), U5.5 (2A), U8.14 (4A)
A1: U1.31 (A1), U2.9 (A1), U5.14 (4A), U8.2 (1A), U26.3
A1_N: U26.4, U43.13 (1C)
A2: U1.32 (A2), U2.8 (A2), U5.2 (1A), U8.5 (2A)
A3: U1.33 (A3), U2.7 (A3), U6.11 (3A), U7.11 (3A)
A4: U1.34 (A4), U2.6 (A4), U6.5 (2A), U7.5 (2A)
A5: U1.35 (A5), U2.5 (A5), U3.9 (A0), U6.2 (1A), U7.2 (1A)
A6: U1.36 (A6), U2.4 (A6), U3.8 (A1), U6.14 (4A), U7.14 (4A)
A7: U1.37 (A7), U2.3 (A7), U5.11 (3A), U8.13 (4B), U25.5
A7_N: U25.6, U28.3
A8: D1.1, U1.38 (A8), U2.25 (A8), U5.6 (2B), U8.3 (1B), U40.2 (A1)
A9: D2.1, U1.39 (A9), U2.24 (A9), U5.13 (4B), U8.6 (2B), U40.3 (A2)
A10: D3.1, U1.40 (A10), U2.21 (A10), U5.3 (1B), U7.10 (3B), U40.4 (A3)
A11: D4.1, U1.1 (A11), U2.23 (A11), U6.10 (3B), U7.6 (2B), U40.5 (A4)
A12: D5.1, U1.2 (A12), U2.2 (A12), U6.6 (2B), U7.3 (1B), U40.6 (A5)
A13: D6.1, U1.3 (A13), U2.26 (A13), U6.3 (1B), U7.13 (4B), U40.7 (A6)
A14: D7.1, U1.4 (A14), U4.36 (A14), U6.13 (4B), U40.8 (A7), U43.5 (2C)
A15: D8.1, U1.5 (A15), U4.37 (A15), U27.10, U40.9 (A8), U43.4 (2B), U43.10 (3B)
AMP_BYP: C87.1, U45.7 (BYPASS)
AMP_IN: RV1.2 (W), U45.3 (+IN)
AMP_OUT: C88.1, R107.1, U45.5 (OUT)
AY_A: R98.1, R101.1, U42.4 (ANALOG_A)
AY_B: R99.1, R102.1, U42.3 (ANALOG_B)
AY_BC1: U42.29 (BC1), U43.6 (2Y)
AY_BDIR: U42.27 (BDIR), U43.8 (3Y)
AY_C: R100.1, R103.1, U42.38 (ANALOG_C)
AY_CLK: U42.22 (CLOCK), U44.5 (1Q)
AY_CLK_N: U44.2 (1D), U44.6 (~1Q)
AY_IOX: U43.3 (2A), U43.9 (3A), U43.12 (1Y)
BANK: U5.10 (3B), U26.2, U26.11
BEEP: J8.9, R104.1, R105.1
CLK: R8.2, T2.3 (C), U1.6 (CLK), U44.3 (1CLK)
D0: R19.1, R35.2, U1.14 (D0), U2.11 (D0), U3.34 (D0), U9.2 (D), U9.14 (Q), U42.37 (DA0)
D1: R20.1, R36.2, U1.15 (D1), U2.12 (D1), U3.33 (D1), U10.2 (D), U10.14 (Q), U42.36 (DA1)
D2: R21.1, R37.2, U1.12 (D2), U2.13 (D2), U3.32 (D2), U11.2 (D), U11.14 (Q), U42.35 (DA2)
D3: R22.1, R38.2, U1.8 (D3), U2.15 (D3), U3.31 (D3), U12.2 (D), U12.14 (Q), U42.34 (DA3)
D4: R23.1, R39.2, U1.7 (D4), U2.16 (D4), U3.30 (D4), U13.2 (D), U13.14 (Q), U42.33 (DA4)
D5: R24.1, R40.2, U1.9 (D5), U2.17 (D5), U3.29 (D5), U14.2 (D), U14.14 (Q), U42.32 (DA5)
D6: R25.1, R41.2, U1.10 (D6), U2.18 (D6), U3.28 (D6), U15.2 (D), U15.14 (Q), U42.31 (DA6)
D7: R26.1, R42.2, U1.13 (D7), U2.19 (D7), U3.27 (D7), U16.2 (D), U16.14 (Q), U42.30 (DA7)
DACB_B: R81.1, U38.8 (3Y)
DACB_G: R79.1, U38.6 (2Y)
DACB_R: R77.1, U38.3 (1Y)
DAC_B: R80.1, U37.14 (1Y2)
DAC_G: R78.1, U37.16 (1Y1)
DAC_R: R76.1, U37.18 (1Y0)
GND: C1.2, C2.2, C4.2, C8.2, C9.2, C10.2, C11.2, C12.2, C13.2, C14.2, C15.2, C20.2, C21.2, C22.2, C23.2, C24.2, C25.2, C26.2, C27.2, C28.2, C29.2, C30.2, C31.2, C32.2, C33.2, C34.2, C35.2, C36.2, C37.2, C38.2, C39.2, C40.2, C41.2, C42.2, C43.2, C44.2, C45.2, C46.2, C47.2, C48.2, C60.2, C61.2, C81.2, C82.2, C83.2, C84.2, C87.2, C89.2, C90.2, C91.2, C93.2, C94.2, C95.2, D11.2, J2.3, J4.26, J5.2, J7.5 (GND), J7.6 (R_GND), J7.7 (G_GND), J7.8 (B_GND), J7.10 (SYNC_GND), J8.8, J8.10, J9.2, J10.S (SLEEVE), LS1.2, R45.2, R84.2, R85.2, R86.2, R87.2, R97.2, R98.2, R99.2, R100.2, R105.2, R106.2, R109.2, RV1.3, SW1.2, T2.1 (E), T3.1 (E), U1.29 (GND), U2.14 (GND), U3.7 (GND), U5.8 (GND), U5.15 (~G), U6.8 (GND), U6.15 (~G), U7.8 (GND), U7.15 (~G), U8.8 (GND), U8.15 (~G), U9.16 (GND), U10.16 (GND), U11.16 (GND), U12.16 (GND), U13.16 (GND), U14.16 (GND), U15.16 (GND), U16.16 (GND), U17.16 (GND), U18.16 (GND), U19.16 (GND), U20.16 (GND), U21.16 (GND), U22.16 (GND), U23.16 (GND), U24.16 (GND), U25.7 (GND), U26.7 (GND), U27.7 (GND), U28.7 (GND), U29.7 (GND), U32.2 (GND), U37.1 (~1OE), U37.10 (GND), U37.13 (2A2), U37.15 (2A1), U37.17 (2A0), U37.19 (~2OE), U38.7 (GND), U38.12 (4A), U38.13 (4B), U39.3 (GND), U39.8 (GND), U39.13 (GND), U39.18 (GND), U39.23 (GND), U39.28 (GND), U39.33 (GND), U39.38 (GND), U40.10 (GND), U40.19 (~OE), U41.7 (GND), U42.1 (GND), U42.24 (~A9), U43.7 (GND), U44.7 (GND), U44.11 (2CLK), U44.12 (2D), U45.2 (-IN), U45.4 (GND); also elsewhere on the board
IORQ_H: U25.8, U28.4, U43.1 (1A)
KA8: D1.2, J1.6
KA9: D2.2, J1.7
KA10: D3.2, J1.8
KA11: D4.2, J1.9
KA12: D5.2, J1.10
KA13: D6.2, J1.11
KA14: D7.2, J1.12
KA15: D8.2, J1.13
KB1: J1.1, R10.2, U4.26 (KB1), U41.2 (1Y)
KB2: J1.2, R11.2, U4.24 (KB2), U41.4 (2Y)
KB3: J1.3, R12.2, U4.23 (KB3), U41.6 (3Y)
KB4: J1.4, R13.2, U4.20 (KB4), U41.8 (4Y)
KB5: J1.5, R14.2, U4.19 (KB5), U41.10 (5Y)
KBD_A8: U39.1 (GP0), U40.18 (B1)
KBD_A9: U39.2 (GP1), U40.17 (B2)
KBD_A10: U39.4 (GP2), U40.16 (B3)
KBD_A11: U39.5 (GP3), U40.15 (B4)
KBD_A12: U39.6 (GP4), U40.14 (B5)
KBD_A13: U39.7 (GP5), U40.13 (B6)
KBD_A14: U39.9 (GP6), U40.12 (B7)
KBD_A15: U39.10 (GP7), U40.11 (B8)
KBD_KB1: R90.2, U39.11 (GP8), U41.1 (1A)
KBD_KB2: R91.2, U39.12 (GP9), U41.3 (2A)
KBD_KB3: R92.2, U39.14 (GP10), U41.5 (3A)
KBD_KB4: R93.2, U39.15 (GP11), U41.9 (4A)
KBD_KB5: R94.2, U39.16 (GP12), U41.11 (5A)
KBD_RST: R95.2, U39.17 (GP13), U41.13 (6A)
KBD_TAPE: R96.1, U39.19 (GP14)
LED_K: D13.1, R45.1
LINE_AC: C92.2, R108.1
LINE_OUT: J10.R (RING), J10.T (TIP), R108.2, R109.1
MG: C4.1, C6.1, D9.2, D11.1, R15.1, U4.28 (MG)
MG_I1: C6.2, R16.1
MG_I2: C7.1, R18.2
MG_IN: C7.2, C85.2, J2.2
MG_O1: C5.1, R15.2
MG_OUT: C5.2, J2.1
MIX: C86.1, C92.1, R101.2, R102.2, R103.2, R104.2, R106.1
MIX_AC: C86.2, RV1.1
MUX1: R34.2, U7.1 (S), U8.1 (S)
MUX2: R44.1, U5.1 (S), U6.1 (S), U29.8
MUX2_D: C9.1, R44.2, U29.5
PA0: J4.1, U3.4 (PA0)
PA1: J4.2, U3.3 (PA1)
PA2: J4.3, U3.2 (PA2)
PA3: J4.4, U3.1 (PA3)
PA4: J4.5, U3.40 (PA4)
PA5: J4.6, U3.39 (PA5)
PA6: J4.7, U3.38 (PA6)
PA7: J4.8, U3.37 (PA7)
PB0: J4.9, U3.18 (PB0)
PB1: J4.10, U3.19 (PB1)
PB2: J4.11, U3.20 (PB2)
PB3: J4.12, U3.21 (PB3)
PB4: J4.13, U3.22 (PB4)
PB5: J4.14, U3.23 (PB5)
PB6: J4.15, U3.24 (PB6)
PB7: J4.16, U3.25 (PB7)
PC0: J4.17, U3.14 (PC0), U26.1
PC1: J4.18, U3.15 (PC1)
PC2: J4.19, U3.16 (PC2)
PC3: J4.20, U3.17 (PC3)
PC4: J4.21, U3.13 (PC4)
PC5: J4.22, U3.12 (PC5)
PC6: J4.23, U3.11 (PC6)
PC7: J4.24, U3.10 (PC7)
PHI: R7.1, U4.32 (Φ)
RA0: U5.7 (2Y), U9.5 (A0), U10.5 (A0), U11.5 (A0), U12.5 (A0), U13.5 (A0), U14.5 (A0), U15.5 (A0), U16.5 (A0)
RA1: U5.12 (4Y), U9.7 (A1), U10.7 (A1), U11.7 (A1), U12.7 (A1), U13.7 (A1), U14.7 (A1), U15.7 (A1), U16.7 (A1)
RA2: U5.4 (1Y), U9.6 (A2), U10.6 (A2), U11.6 (A2), U12.6 (A2), U13.6 (A2), U14.6 (A2), U15.6 (A2), U16.6 (A2)
RA3: U6.9 (3Y), U9.12 (A3), U10.12 (A3), U11.12 (A3), U12.12 (A3), U13.12 (A3), U14.12 (A3), U15.12 (A3), U16.12 (A3)
RA4: U6.7 (2Y), U9.11 (A4), U10.11 (A4), U11.11 (A4), U12.11 (A4), U13.11 (A4), U14.11 (A4), U15.11 (A4), U16.11 (A4)
RA5: U6.4 (1Y), U9.10 (A5), U10.10 (A5), U11.10 (A5), U12.10 (A5), U13.10 (A5), U14.10 (A5), U15.10 (A5), U16.10 (A5)
RA6: U6.12 (4Y), U9.13 (A6), U10.13 (A6), U11.13 (A6), U12.13 (A6), U13.13 (A6), U14.13 (A6), U15.13 (A6), U16.13 (A6)
RA7: U5.9 (3Y), U9.9 (A7), U10.9 (A7), U11.9 (A7), U12.9 (A7), U13.9 (A7), U14.9 (A7), U15.9 (A7), U16.9 (A7)
RAS_D: C8.1, R43.2, U29.9
RESET: U3.35 (RESET), U25.12
RGB_B: J8.3, R86.1, U37.6 (1A2), U38.9 (3A)
RGB_G: J8.2, R85.1, U37.4 (1A1), U38.4 (2A)
RGB_I: J8.4, R87.1, U38.2 (1B), U38.5 (2B), U38.10 (3B)
RGB_R: J8.1, R84.1, U37.2 (1A0), U38.1 (1A)
RW: U27.6, U27.9
SPK_D: D9.1, D10.2
SPK_K: D10.1, LS1.1
SPK_OUT: C88.2, J9.1
T2_B: R7.2, T2.2 (B)
T3_B: R16.2, T3.2 (B)
T3_C: R17.2, R18.1, T3.3 (C)
TAPE_DIV: C85.1, R96.2, R97.1
ULA_UPE: R9.2, U4.13 (UPE)
VA0: R27.2, U4.7 (DRAM_A0), U17.5 (A0), U18.5 (A0), U19.5 (A0), U20.5 (A0), U21.5 (A0), U22.5 (A0), U23.5 (A0), U24.5 (A0)
VA1: R28.2, U4.6 (DRAM_A1), U17.11 (A4), U18.11 (A4), U19.11 (A4), U20.11 (A4), U21.11 (A4), U22.11 (A4), U23.11 (A4), U24.11 (A4)
VA2: R29.2, U4.5 (DRAM_A2), U17.7 (A1), U18.7 (A1), U19.7 (A1), U20.7 (A1), U21.7 (A1), U22.7 (A1), U23.7 (A1), U24.7 (A1)
VA3: R30.2, U4.8 (DRAM_A3), U17.13 (A6), U18.13 (A6), U19.13 (A6), U20.13 (A6), U21.13 (A6), U22.13 (A6), U23.13 (A6), U24.13 (A6)
VA4: R31.2, U4.9 (DRAM_A4), U17.12 (A3), U18.12 (A3), U19.12 (A3), U20.12 (A3), U21.12 (A3), U22.12 (A3), U23.12 (A3), U24.12 (A3)
VA5: R32.2, U4.10 (DRAM_A5), U17.10 (A5), U18.10 (A5), U19.10 (A5), U20.10 (A5), U21.10 (A5), U22.10 (A5), U23.10 (A5), U24.10 (A5)
VA6: R33.2, U4.11 (DRAM_A6), U17.6 (A2), U18.6 (A2), U19.6 (A2), U20.6 (A2), U21.6 (A2), U22.6 (A2), U23.6 (A2), U24.6 (A2)
VD0: R19.2, U4.18 (D0), U17.2 (D), U17.14 (Q)
VD1: R20.2, U4.21 (D1), U18.2 (D), U18.14 (Q)
VD2: R21.2, U4.22 (D2), U19.2 (D), U19.14 (Q)
VD3: R22.2, U4.25 (D3), U20.2 (D), U20.14 (Q)
VD4: R23.2, U4.27 (D4), U21.2 (D), U21.14 (Q)
VD5: R24.2, U4.29 (D5), U22.2 (D), U22.14 (Q)
VD6: R25.2, U4.30 (D6), U23.2 (D), U23.14 (Q)
VD7: R26.2, U4.31 (D7), U24.2 (D), U24.14 (Q)
VGA_B: J7.3 (BLUE), R80.2, R81.2
VGA_G: J7.2 (GREEN), R78.2, R79.2
VGA_HS: J7.13 (HSYNC), R82.2
VGA_HS_D: R82.1, U37.12 (1Y3)
VGA_R: J7.1 (RED), R76.2, R77.2
VGA_VS: J7.14 (VSYNC), R83.2
VGA_VS_D: R83.1, U37.9 (2Y3)
VIN: C11.1, C12.1, C90.1, C91.1, D12.1, U32.1 (IN), U45.6 (VS)
VIN_F: D12.2, F1.2
VIN_RAW: F1.1, J5.1
VM0: R27.1, U8.12 (4Y)
VM1: R28.1, U8.4 (1Y)
VM2: R29.1, U8.7 (2Y)
VM3: R30.1, U7.9 (3Y)
VM4: R31.1, U7.7 (2Y)
VM5: R32.1, U7.4 (1Y)
VM6: R33.1, U7.12 (4Y)
WR_D: U25.4, U27.5
WR_I: U25.2, U25.3, U43.11 (3C)
XTAL1: U4.39 (XTAL1), Y1.1
XTAL2: C3.2, U4.40 (XTAL2)
XTAL_C: C3.1, Y1.2
ZOBEL: C89.1, R107.2

Notes on the sheet:
DIDAKTIK GAMA – SCHÉMA ZAPOJENIA (překresleno z tištěné předlohy)
Spoje jsou vedeny návěštími (labels) – stejné jméno = stejný net. ~{X} = aktivní v nule.
K OVĚŘENÍ (na předloze nečitelné / odhadnuté):
• U2 pin 20 (/CE): /ROMCS = ULA pin 34 – U pinu 20 je jen kondenzátor 100p; připojení na ULA ROMCS je odhad
• U4 (ULA): pin GND není ve schématu nakreslen – Čísla pinů 36/37 (A14/A15) a 2 (/WR) jsou na předloze rozmazaná – převzato dle zapojení ZX ULA
• MG / zvuk (D9–D11, LS1, T3): horní konce reproduktoru, diod a 10n – Na předloze končí bez označení – připojeno na GND; zapojení KC507 přepsáno doslova, ověřit
• U4 patice ULA: osadit modul s CPLD (XC95144XL + firmware zx_ula, GPL) místo originální ULA – Modul je samostatná deska (40 vývodů do patice + výstup RGB na J8) – zatím nenakreslen; piny 15–17 (U, V, Y) nezapojeny
• J8 / VGA výstup: digitální RGB + BRIGHT + CSYNC/VSYNC z modulu, 15,6 kHz – Běžný VGA monitor chce 31 kHz – potřeba monitor s 15 kHz nebo převodník (GBS-8200, OSSC, RetroTINK)
• R76–R81 (převodník): 680R + 1k5 do 75R monitoru: 0,50 V normální, 0,69 V jas – Vypočteno pro výstup 74HCT244 při 5 V; přesnost závisí na výstupním odporu hradla
• R96, R97, C85 (přehrávač kazet): GP14 Pica -> MG_IN, úroveň ~0,6 V jako výstup magnetofonu – Při nahrávání nemít připojený skutečný magnetofon (oba výstupy by se sčítaly); úroveň případně upravit R97
• U39 Raspberry Pi Pico: USB host přes micro-USB a redukci OTG, napájení +5V do VBUS (pin 40) – Potřebuje firmware (TinyUSB host HID + emulace matice 8x5); pull-upy 10k drží KB1–5 a /RESET uvolněné, dokud Pico nenaběhne
• U40/U41 74LVC245, 74LVC07: převod úrovní 5 V <-> 3,3 V – Vstupy LVC snesou 5 V při napájení 3,3 V; 74LVC07 má otevřený kolektor – KB linky dál táhnou původní pull-upy 10k na +5V
• U42 YM2149F: pinout ověřen katalogovým listem Yamaha YM2149 (1992) – Pin 26 /SEL nezapojen – vnitřní pull-up = hodiny bez dělení (1,75 MHz jako AY); totéž funguje s AY-3-8910
• U43 dekódování AY: FFFD = výběr registru, BFFD = data (A15, A14, A1, IORQ, WR, /M1) – Shodné s portem Spectra 128K; Gama 8255 (A7=0, A1=1) ani ULA (A0=0) nekolidují
• Zvuk – mix a LM386: BEEP 10k + AY 3x 4k7 do 2k2, hlasitost 10k, LM386 z VIN 9 V – Poměr hlasitosti beeperu a AY podle sluchu (R104); LS1 a D9/D10 z původního zapojení neosazovat, reproduktor na J9
• R27–R33 (330R): oddělení multiplexeru od adresy DRAM – S modulem CPLD (3,3 V) zvážit 470R – omezí proud do výstupů CPLD, když ULA přebíjí multiplexer
• U7/U8 vstupy: přiřazení A/B vstupů LS157 – Na předloze jsou vidět jen odbočky z adresové sběrnice – řádek An / sloupec An+7 je odvozeno funkčně
• U5 pin 10: sloupcový bit RA7 = BANK (PC0 8255) – Funkční odhad: horních 32K je 2x32K banka přepínaná PC0
• U27 pin 10: = A15 – Vstup přichází z adresové sběrnice, konkrétní linka nečitelná
• U28 (CS 8255): 3vstupé NAND: ~A7, IORQ, /M1 – Typ hradla a třetí vstup (/M1) odhadnuty; port 8255 = A7=0 (1Fh/3Fh/5Fh/7Fh)
• U29D (/WE64): vstupy 12 = /WR, 13 = /MREQ – Výstup 11 jde na /WE 4164 – vstupy na předloze nejasné
• C9: 100p z MUX2_D na GND – Druhý konec kondenzátoru na předloze nejasný
• U32 spínaný stabilizátor: R-78E5.0-1.0 místo MA7805 (stejné vývody IN-GND-OUT) – Méně tepla (účinnost ~90 %); při rušení obrazu lze vrátit MA7805 na chladiči
• Napájení (J5, F1, D12, U32): celý blok doplněn – Na předloze není – 9 V nestabilizovaných + 7805 odpovídá servisnímu manuálu ZX Spectrum 128 (zdroj ZX power pack); u Gamy ověřit na adaptéru
• C20–C61: blokování napájení – Doplněno: 100n u každého IC (u napájecích pinů), 47u u bank 4164 a 2118
VGA VÝSTUP (digitální RGB z modulu ULA s CPLD, 15 kHz)
NAPÁJENÍ (doplněno – na předloze jen +5V)
ZVUK: YM2149/AY (porty FFFD/BFFD jako Spectrum 128K) + BEEP z modulu -> LM386 a linkový výstup
USB KLÁVESNICE (RPi Pico jako USB host, emulace matice A8–A15 / KB1–KB5)

Board: 4 copper layers, 212 parts (0 on the bottom side), 202 nets, no tracks yet.

Other parts of the board:
H1, H2, H3, H4: MountingHole_3.2mm_M3_Pad

Their connections:
GND: H1.1, H2.1, H3.1, H4.1; also elsewhere on the board

File hardware/didaktik-gama/bom.csv:

skupina,hodnota,pocet,reference,pouzdro
CPU,UA880D (Z80),1,U1,Package_DIP:DIP-40_W15.24mm
Dioda,1N5822 (Schottky 3A),1,D12,Diode_THT:D_DO-201AD_P15.24mm_Horizontal
Dioda,KA136,11,D1 D2 D3 D4 D5 D6 D7 D8 D9 D10 D11,Diode_THT:D_DO-35_SOD27_P7.62mm_Horizontal
I/O,8255 (MHB8255),1,U3,Package_DIP:DIP-40_W15.24mm
Klávesnice USB,74LVC07,1,U41,Package_SO:SOIC-14_3.9x8.7mm_P1.27mm
Klávesnice USB,74LVC245,1,U40,Package_SO:SOIC-20W_7.5x12.8mm_P1.27mm
Klávesnice USB,Raspberry Pi Pico (USB host),1,U39,gama:RaspberryPi_Pico_THT
Kondenzátor,1000u/25V,1,C11,Capacitor_THT:CP_Radial_D10.0mm_P5.00mm
Kondenzátor,100n,42,C5 C6 C7 C12 C13 C20 C21 C22 C23 C24 C25 C26 C27 C28 C29 C30 C31 C32 C33 C34 C35 C36 C37 C38 C39 C40 C41 C42 C43 C44 C45 C46 C47 C48 C81 C82 C83 C84 C91 C93 C94 C95,Capacitor_THT:C_Disc_D5.0mm_W2.5mm_P5.00mm
Kondenzátor,100p,3,C2 C9 C10,Capacitor_THT:C_Disc_D5.0mm_W2.5mm_P5.00mm
Kondenzátor,100u/25V,1,C90,Capacitor_THT:CP_Radial_D6.3mm_P2.50mm
Kondenzátor,10n,1,C4,Capacitor_THT:C_Disc_D5.0mm_W2.5mm_P5.00mm
Kondenzátor,10u/16V,1,C15,Capacitor_THT:CP_Radial_D5.0mm_P2.00mm
Kondenzátor,10u/16V,3,C86 C87 C92,Capacitor_THT:CP_Radial_D6.3mm_P2.50mm
Kondenzátor,1u/16V,1,C85,Capacitor_THT:CP_Radial_D5.0mm_P2.00mm
Kondenzátor,220u/10V,1,C14,Capacitor_THT:CP_Radial_D6.3mm_P2.50mm
Kondenzátor,220u/16V,1,C88,Capacitor_THT:CP_Radial_D6.3mm_P2.50mm
Kondenzátor,2u,1,C1,Capacitor_THT:CP_Radial_D5.0mm_P2.50mm
Kondenzátor,47n,1,C89,Capacitor_THT:C_Disc_D5.0mm_W2.5mm_P5.00mm
Kondenzátor,47p,2,C3 C8,Capacitor_THT:C_Disc_D5.0mm_W2.5mm_P5.00mm
Kondenzátor,47u/10V,2,C60 C61,Capacitor_THT:CP_Radial_D5.0mm_P2.00mm
Konektor,Klávesnice,1,J1,Connector_PinHeader_2.54mm:PinHeader_1x14_P2.54mm_Vertical
Konektor,"Linkový výstup (jack 3,5 mm)",1,J10,Connector_Audio:Jack_3.5mm_CUI_SJ1-3523N_Horizontal
Konektor,MG,1,J2,Connector_PinHeader_2.54mm:PinHeader_1x03_P2.54mm_Vertical
Konektor,Napájení 9–12V DC,1,J5,Connector_BarrelJack:BarrelJack_Horizontal
Konektor,Porty 8255,1,J4,Connector_PinHeader_2.54mm:PinHeader_2x13_P2.54mm_Vertical
Konektor,RGB + zvuk z modulu ULA,1,J8,Connector_PinHeader_2.54mm:PinHeader_1x10_P2.54mm_Vertical
Konektor,Reproduktor 8 ohm,1,J9,Connector_PinHeader_2.54mm:PinHeader_1x02_P2.54mm_Vertical
Konektor,VGA DE-15 (RGB 15 kHz),1,J7,Connector_Dsub:DSUB-15-HD_Female_Horizontal_P2.29x1.98mm_EdgePinOffset3.03mm_Housed_MountingHolesOffset4.94mm
Logika,74LS00,1,U27,Package_DIP:DIP-14_W7.62mm
Logika,74LS04,2,U25 U26,Package_DIP:DIP-14_W7.62mm
Logika,74LS10,1,U28,Package_DIP:DIP-14_W7.62mm
Logika,74LS32,1,U29,Package_DIP:DIP-14_W7.62mm
Multiplexer,74LS157,4,U5 U6 U7 U8,Package_DIP:DIP-16_W7.62mm
Napájení,1A T,1,F1,Fuse:Fuseholder_Cylinder-5x20mm_Stelvio-Kontek_PTF78_Horizontal_Open
Napájení,LED zelená,1,D13,LED_THT:LED_D5.0mm
Napájení,"R-78E5.0-1.0 (spínaný, náhrada 7805)",1,U32,Converter_DCDC:Converter_DCDC_RECOM_R-78E-0.5_THT
Ostatní,14MHz,1,Y1,Crystal:Crystal_HC49-4H_Vertical
Ostatní,RESET,1,SW1,Button_Switch_THT:SW_PUSH_6mm
Ostatní,Reproduktor,1,LS1,Connector_PinHeader_2.54mm:PinHeader_1x02_P2.54mm_Vertical
RAM 4164,4164,8,U9 U10 U11 U12 U13 U14 U15 U16,Package_DIP:DIP-16_W7.62mm
ROM,27128 (16K EPROM),1,U2,Package_DIP:DIP-28_W15.24mm
Rezistor,100,1,R34,Resistor_THT:R_Axial_DIN0207_L6.3mm_D2.5mm_P10.16mm_Horizontal
Rezistor,100k,1,R105,Resistor_THT:R_Axial_DIN0207_L6.3mm_D2.5mm_P10.16mm_Horizontal
Rezistor,10R,1,R107,Resistor_THT:R_Axial_DIN0207_L6.3mm_D2.5mm_P10.16mm_Horizontal
Rezistor,10k,23,R1 R2 R3 R10 R11 R12 R13 R14 R15 R84 R85 R86 R87 R88 R89 R90 R91 R92 R93 R94 R95 R96 R104,Resistor_THT:R_Axial_DIN0207_L6.3mm_D2.5mm_P10.16mm_Horizontal
Rezistor,15,1,R9,Resistor_THT:R_Axial_DIN0207_L6.3mm_D2.5mm_P10.16mm_Horizontal
Rezistor,180,1,R8,Resistor_THT:R_Axial_DIN0207_L6.3mm_D2.5mm_P10.16mm_Horizontal
Rezistor,1k,6,R7 R17 R98 R99 R100 R108,Resistor_THT:R_Axial_DIN0207_L6.3mm_D2.5mm_P10.16mm_Horizontal
Rezistor,1k5,3,R77 R79 R81,Resistor_THT:R_Axial_DIN0207_L6.3mm_D2.5mm_P10.16mm_Horizontal
Rezistor,220,2,R43 R44,Resistor_THT:R_Axial_DIN0207_L6.3mm_D2.5mm_P10.16mm_Horizontal
Rezistor,220k,1,R4,Resistor_THT:R_Axial_DIN0207_L6.3mm_D2.5mm_P10.16mm_Horizontal
Rezistor,2k2,2,R97 R106,Resistor_THT:R_Axial_DIN0207_L6.3mm_D2.5mm_P10.16mm_Horizontal
Rezistor,330,7,R27 R28 R29 R30 R31 R32 R33,Resistor_THT:R_Axial_DIN0207_L6.3mm_D2.5mm_P10.16mm_Horizontal
Rezistor,330k,1,R18,Resistor_THT:R_Axial_DIN0207_L6.3mm_D2.5mm_P10.16mm_Horizontal
Rezistor,470,11,R5 R6 R19 R20 R21 R22 R23 R24 R25 R26 R45,Resistor_THT:R_Axial_DIN0207_L6.3mm_D2.5mm_P10.16mm_Horizontal
Rezistor,47k,1,R109,Resistor_THT:R_Axial_DIN0207_L6.3mm_D2.5mm_P10.16mm_Horizontal
Rezistor,4k7,3,R101 R102 R103,Resistor_THT:R_Axial_DIN0207_L6.3mm_D2.5mm_P10.16mm_Horizontal
Rezistor,680,4,R16 R76 R78 R80,Resistor_THT:R_Axial_DIN0207_L6.3mm_D2.5mm_P10.16mm_Horizontal
Rezistor,75,2,R82 R83,Resistor_THT:R_Axial_DIN0207_L6.3mm_D2.5mm_P10.16mm_Horizontal
Rezistor,8k2,8,R35 R36 R37 R38 R39 R40 R41 R42,Resistor_THT:R_Axial_DIN0207_L6.3mm_D2.5mm_P10.16mm_Horizontal
Tranzistor,KC507,1,T3,Package_TO_SOT_THT:TO-18-3
Tranzistor,KSY72,2,T1 T2,Package_TO_SOT_THT:TO-18-3
ULA,ULA,1,U4,Package_DIP:DIP-40_W15.24mm
Video,74HCT08,1,U38,Package_DIP:DIP-14_W7.62mm
Video,74HCT244,1,U37,Package_DIP:DIP-20_W7.62mm
Video RAM 2118,2118,8,U17 U18 U19 U20 U21 U22 U23 U24,Package_DIP:DIP-16_W7.62mm
Zvuk,10k log (hlasitost),1,RV1,Potentiometer_THT:Potentiometer_Alps_RK09K_Single_Vertical
Zvuk,74HCT11,1,U43,Package_DIP:DIP-14_W7.62mm
Zvuk,74HCT74,1,U44,Package_DIP:DIP-14_W7.62mm
Zvuk,LM386N-1,1,U45,Package_DIP:DIP-8_W7.62mm
Zvuk,YM2149F (nebo AY-3-8910),1,U42,Package_DIP:DIP-40_W15.24mm
